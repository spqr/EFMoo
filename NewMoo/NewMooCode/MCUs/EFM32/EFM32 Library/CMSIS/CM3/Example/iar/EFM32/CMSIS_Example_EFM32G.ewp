# IAR project CMSIS_Example_EFM32G.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 EnergyMicro EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128
  ICCARM.CCIncludePath2: ..\..\..\CoreSupport; ..\..\..\DeviceSupport\EnergyMicro\EFM32
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32G890F128
  OBJCOPY.OOCOutputFile: CMSIS_Example_EFM32G.srec
  ILINK.IlinkOutputFile: CMSIS_Example_EFM32G.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32G890F128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../CoreSupport/: core_cm3.c
    ./: dvkreg.c main_efm32.c
    ../../../DeviceSupport/EnergyMicro/EFM32/startup/iar/: startup_efm32.s
    ../../../DeviceSupport/EnergyMicro/EFM32/: system_efm32.c
