# IAR project NewMooIAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32G890F128 EnergyMicro EFM32G890F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\NewMooCode\; ..\NewMooCode\Accel\; ..\NewMooCode\Globals and RegVars\; ..\NewMooCode\Globals and RegVars\EFM32\; ..\NewMooCode\Interrupts\; ..\NewMooCode\Interrupts\EFM32\; ..\NewMooCode\MCUs\; ..\NewMooCode\MCUs\EFM32\; ..\NewMooCode\Moo\; ..\NewMooCode\RFID\; ..\NewMooCode\Sessions\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Accel
    ../NewMooCode/Accel/: quick_accel_sensor.c quick_accel_sensor.h
  group Globals and Regvars
    ../NewMooCode/Globals and RegVars/: globals_regvars.h
  group Globals and Regvars/EFM32
    ../NewMooCode/Globals and RegVars/EFM32/: EFM32_globals_regvars.h
  group Interrupts
    ../NewMooCode/Interrupts/: interrupts.h
  group Interrupts/EFM32
    ../NewMooCode/Interrupts/EFM32/: EFM32_interrupts.h
  group MCUs
    ../NewMooCode/MCUs/: mcu.h
  group MCUs/EFM32
    ../NewMooCode/MCUs/EFM32/: EFM32_mcu.h
  group Moo
    ../NewMooCode/Moo/: moo_main.c moo_main.h moo_runmode.c moo_runmode.h mymoo.h
  group RFID
    ../NewMooCode/RFID/: rfid.c rfid.h
  group Sessions
    ../NewMooCode/Sessions/: sessions.c sessions.h
