# IAR project NewMooIAR.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\NewMooCode\; ..\NewMooCode\Accel\; ..\NewMooCode\Globals and RegVars\; ..\NewMooCode\Globals and RegVars\MSP430\; ..\NewMooCode\Interrupts\; ..\NewMooCode\Interrupts\MSP430\; ..\NewMooCode\MCUs\; ..\NewMooCode\MCUs\MSP430\; ..\NewMooCode\Moo\; ..\NewMooCode\RFID\; ..\NewMooCode\Sessions\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2131.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group Accel
    ../NewMooCode/Accel/: quick_accel_sensor.c quick_accel_sensor.h
  group Globals and RegVars
    ../NewMooCode/Globals and RegVars/: globals_regvars.h
  group Globals and RegVars/MSP430
    ../NewMooCode/Globals and RegVars/MSP430/: MSP430_globals_regvars.h
  group Interrupts
    ../NewMooCode/Interrupts/: interrupts.h
  group Interrupts/MSP430
    ../NewMooCode/Interrupts/MSP430/: MSP430_interrupts.c MSP430_interrupts.h
  group MCUs
    ../NewMooCode/MCUs/: mcu.h
  group MCUs/MSP430
    ../NewMooCode/MCUs/MSP430/: MSP430_mcu.c MSP430_mcu.h
  group Moo
    ../NewMooCode/Moo/: moo_main.c moo_main.h moo_runmode.c moo_runmode.h mymoo.h
  group RFID
    ../NewMooCode/RFID/: rfid.c rfid.h
  group Sessions
    ../NewMooCode/Sessions/: sessions.c sessions.h
